# Repository poypok/Nano-X-ESP

## KiCad design Nano X ESP V3.kicad_pcb

Parts:
.1, .2: logo
AE1: Antenna_Shield; U.FL_Molex_MCRF_73412-0110_Vertical
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C7, C8, C10: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C9, C11: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 10uF; CP_EIA-3216-12_Kemet-S
H1, H2: MountingHole; MountingHole_4.3mm_M4_ISO14580
J1, J2: Conn_ESP; Molex_KK-254_AE-6410-06A_1x06_P2.54mm_Vertical
J3, J4: Conn_Atmega; Molex_KK-254_AE-6410-11A_1x11_P2.54mm_Vertical
J5: Conn_FT232; Molex_KK-254_AE-6410-06A_1x06_P2.54mm_Vertical
J6: CONN_SIM800l; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J7: CONN_Input; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J8: Conn_ICSP; PinSocket_2x03_P2.54mm_Vertical
J9: Conn_I2C; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J10: Conn_Output; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
JP1: SolderJumper_ESP+; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: Bypass_VoltReg; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: SolderJumper_Arduino+; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: Bypass_AtMega; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5: Bypass_GND_Sim800l; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP6: Bypass_Sim800l; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q2: S8050; SOT-23
R1: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4, R5, R8, R9, R10, R11, R12: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Reset; SW_SPST_FSMSM
SW2: SW_RESET; SW_SPST_FSMSM
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: ATmega328-AU; TQFP-32_7x7mm_P0.8mm
U3: ESP-07
U4: RFM95W-868S2; HOPERF_RFM9XW_SMD
U5: SIM800; sim800l
Y1: 16.000 Mhz; Crystal_SMD_HC49-SD

Connections:
+3V3: C6.1, J10.2, JP1.1 (A), JP2.1 (A), JP4.1 (A), JP6.1 (A), U1.2 (VO), U4.13 (3.3V)
+4V: J6.2, JP6.2 (B), U5.2
+5V: C4.1, J5.6, J7.2, J8.2, J9.1, J10.3, JP2.2 (B), JP3.1 (A), U1.3 (VI)
/A0: J3.1, U2.23 (PC0)
/A1: J3.2, U2.24 (PC1)
/A2: J3.3, U2.25 (PC2)
/A3: J3.4, U2.26 (PC3)
/A4: J2.3, J3.5, J9.4, U2.27 (PC4), U3.13 (GPIO4)
/A5: J2.4, J3.6, J9.3, U2.28 (PC5), U3.14 (GPIO5)
/A6: J3.7, U2.19 (ADC6)
/A7: J3.8, U2.22 (ADC7)
/ADC: R10.1, R12.2, U3.2 (ADC)
/ADCIN: J1.1, R12.1
/CS: J1.6, J4.8, R11.1, U2.14 (PB2), U3.10 (GPIO15), U4.5 (NSS)
/D0: J2.5, J3.9, J5.1, U2.30 (PD0), U3.15 (GPIO3/RXD), U5.5
/D1: J2.6, J3.10, J5.2, U2.31 (PD1), U3.16 (GPIO1/TXD), U5.4
/D2: J2.1, J3.11, R5.1, U2.32 (PD2), U3.11 (GPIO2), U4.14 (DIO0)
/D3: J4.1, U2.1 (PD3)
/D4: J4.2, U2.2 (PD4)
/D5: J4.3, U2.9 (PD5)
/D6: J4.4, U2.10 (PD6)
/D7: J4.5, U2.11 (PD7)
/D8: J4.6, U2.12 (PB0)
/D9: J4.7, U2.13 (PB1)
/D11: J1.5, J4.9, J8.3, U2.15 (PB3), U3.7 (GPIO13), U4.3 (MOSI)
/D12: J1.4, J4.10, J8.1, U2.16 (PB4), U3.6 (GPIO12), U4.2 (MISO)
/D13: J1.3, J4.11, J8.5, U2.17 (PB5), U3.5 (GPIO14), U4.4 (SCK)
/DTR: C1.1, J5.4, Q2.1 (E), R8.2
/EN: R3.1, U3.3 (EN)
/GPIO0: J2.2, Q1.1 (E), R4.1, U3.12 (GPIO0)
/GPIO16: J1.2, U3.4 (GPIO16)
/RESET: C1.2, J8.4, R1.2, SW1.1, U2.29 (~RESET~/PC6)
/RST: C9.2, Q2.3 (C), R2.1, SW2.2, U3.1 (~RST)
/RST_GSM: U5.3
/RTS: J5.3, Q1.3 (C), R9.2
/XTAL1: C3.1, U2.7 (XTAL1/PB6), Y1.2
/XTAL2: C2.2, U2.8 (XTAL2/PB7), Y1.1
GND: AE1.2 (Shield), C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.1, J5.5, J7.1, J8.6, J9.2, J10.1, JP5.1 (A), R10.2, R11.2, SW1.2, SW2.1, U1.1 (GND), U2.3 (GND), U2.5 (GND), U2.21 (GND), U3.9 (GND), U4.1 (GND), U4.8 (GND), U4.10 (GND)
GND1: J6.1, JP5.2 (B), U5.6
unnamed: AE1.1 (A), U4.9 (ANT)
unnamed: C5.1, U2.20 (AREF)
unnamed: Q1.2 (B), R8.1
unnamed: Q2.2 (B), R9.1
VCC: C7.1, C8.1, JP3.2 (B), JP4.2 (B), R1.1, U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC)
VDD: C10.1, C11.2, JP1.2 (B), R2.2, R3.2, R4.2, R5.2, U3.8 (VCC)

Notes on the sheet:
Atmega-328
ESP 8266
SIM800 Management
Power Distribution Block
LORA Management
Power & I/O Connector
Jumper Connector
Connector
Minimum System Block
Comunication System Block

Board: 2 copper layers, 98.0 x 68.0 mm, 52 parts (21 on the bottom side), 44 nets.

File BOMFILE/BOM file.xlsx:

No | Sourced | Placed | References | Value | Footprint | Quantity
1 |  |  | C4, C6, C7, C8, C10 | 10uF | C_0805_2012Metric_Pad1.18x1.45mm_HandSolder | 5
2 |  |  | C5, C9, C11 | 10nF | C_0805_2012Metric_Pad1.18x1.45mm_HandSolder | 3
3 |  |  | C2, C3 | 22pF | C_0805_2012Metric_Pad1.18x1.45mm_HandSolder | 2
4 |  |  | C1 | 100nF | C_0805_2012Metric_Pad1.18x1.45mm_HandSolder | 1
5 |  |  | R2, R3, R4, R5, R8, R9, R10, R11, R12 | 10K | R_0805_2012Metric_Pad1.20x1.40mm_HandSolder | 9
6 |  |  | R1 | 1K | R_0805_2012Metric_Pad1.20x1.40mm_HandSolder | 1
7 |  |  | U3 | ESP-07 | ESP-07 | 1
8 |  |  | U4 | RFM95W-868S2 | HOPERF_RFM9XW_SMD | 1
9 |  |  | U1 | AMS1117-3.3 | SOT-223-3_TabPin2 | 1
10 |  |  | U2 | ATmega328-AU | TQFP-32_7x7mm_P0.8mm | 1
11 |  |  | U5 | SIM800 | sim800l | 1
12 |  |  | Y1 | 16.000 Mhz | Crystal_SMD_HC49-SD | 1
13 |  |  | SW1 | SW_Reset | SW_SPST_FSMSM | 1
14 |  |  | SW2 | SW_RESET | SW_SPST_FSMSM | 1
15 |  |  | Q1, Q2 | S8050 | SOT-23 | 2
16 |  |  | AE1 | Antenna_Shield | U.FL_Molex_MCRF_73412-0110_Vertical | 1
17 |  |  | J6 | CONN_SIM800l | PinHeader_1x02_P2.54mm_Vertical | 1
18 |  |  | J7 | CONN_Input | PinHeader_1x02_P2.54mm_Vertical | 1
19 |  |  | J10 | Conn_Output | PinHeader_1x03_P2.54mm_Vertical | 1
20 |  |  | J9 | Conn_I2C | PinHeader_1x04_P2.54mm_Vertical | 1
21 |  |  | J1, J3 | Conn_ESP | PinHeader_1x06_P2.54mm_Vertical | 2
22 |  |  | J5 | Conn_FT232 | PinHeader_1x06_P2.54mm_Vertical | 1
23 |  |  | J8 | Conn_SPI | PinHeader_1x06_P2.54mm_Vertical | 1
24 |  |  | J2, J4 | Conn_Atmega | PinHeader_1x11_P2.54mm_Vertical | 2
